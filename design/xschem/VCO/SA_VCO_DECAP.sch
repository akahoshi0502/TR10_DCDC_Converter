v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 280 -30 340 -30 {lab=xxx}
N 280 -10 340 -10 {lab=#net1}
C {VCO/SA_VCO_DECAP_B.sym} 130 -20 0 0 {name=x1<22:0>}
C {devices/iopin.sym} 340 -30 0 0 {name=p1 lab=VDD
}
C {devices/iopin.sym} 340 -10 0 0 {name=p2 lab=VSS
}
